# Keil uVision project flight.uvproj, settings and files
target STM32F405RG (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: flight
  c flags: Optim=1 OneElfS=1 wLevel=2
  group Libraries
    ./Libraries/: CoordinateConversions.c WorldMagModel.c fifo_buffer.c
  group Modules_Actuator
    ./Modules/Actuator/: actuator.c
  group Modules_Altitude
    ./Modules/Altitude/: altitude.c
  group Modules_Attitude
    ./Modules/Attitude/: attitude.c
  group Modules_Battery
    ./Modules/Battery/: battery.c
  group Modules_Example
    ./Modules/Example/: example.c examplemodevent.c examplemodperiodic.c examplemodthread.c
  group Modules_FirmwareIAP
    ./Modules/FirmwareIAP/: firmwareiap.c
  group Modules_FlightPlan
    ./Modules/FlightPlan/: flightplan.c
  group Modules_GPS
    ./Modules/GPS/: GPS.c NMEA.c
  group Modules_MK_MKSerial
    ./Modules/MK/MKSerial/: MKSerial.c
  group Modules_ManualControl
    ./Modules/ManualControl/: manualcontrol.c
  group Modules_Osd_OsdEtStd
    ./Modules/Osd/OsdEtStd/: OsdEtStd.c
  group Modules_Stabilization
    ./Modules/Stabilization/: stabilization.c
  group Modules_System
    ./Modules/System/: systemmod.c
  group Modules_Telemetry
    ./Modules/Telemetry/: telemetry.c
  group PiOS_Common
    ./PiOS/Common/: pios_adxl345.c pios_bma180.c pios_bmp085.c pios_board_info.c pios_com.c pios_crc.c pios_hcsr04.c pios_hmc5843.c pios_i2c_esc.c pios_iap.c pios_sdcard.c
  group Startup
    ./Startup/: startup_stm32f40_41xxx_arm.s
  group UAVObjects
    ./UAVObjects/: eventdispatcher.c uavobjectmanager.c
  group UAVTalk
    ./UAVTalk/: uavtalk.c
  group StdPeriph
    ./pios/stm32f4xx/libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
